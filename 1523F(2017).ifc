Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-12T13:49:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 12 13:49:27 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{18A56DE4-8733-4354-A373-7C622FBD6CDB}\ifc * Database version: 5507 * Database creation date: Wed Jun 12 13:49:25 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 12 13:49:26 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 12 13:49:26 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1523F Kitchen faucet, Energy Class C, 1523F(2017):1523F Kitchen faucet, Energy Class C:319262
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; NominalDepth: 242.9 mm; NominalHeight: 300.7 mm; NominalWidth: 49.1 mm; Projection: 208 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1523F(2017); ConvergoRefNr: 0087-1906-0033-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 10/06/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150086861; EN Standard: EN 817; Noise Class: I (ISO 3822) Oras lab.; RSK Number: 8310969; VVS Number: 705937704
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1523F; Catalog Drawing URL: http://static.oras.com/catdrw/1523F; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1523F; FDV Document URL: http://www.oras.com/datasheet/1523F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1523F; Group: Kitchen faucets; Manufacturer: Oras; Model: 1523F Kitchen faucet, Energy Class C; Name_en: 1523F Kitchen faucet, Energy Class C; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 754 x 334 x 63; Package Weight: 1.380 kg; Product Code: 1523F; Product Datasheet: http://www.oras.com/datasheet/1523F/en; Product Family: Oras Swea; Product Image URL: http://static.oras.com/image/1523F; Product URL: http://static.oras.com/1523F; Type Name: 1523F Kitchen faucet, Energy Class C
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: G3/8; Eco Flow At 300kPa: 0.00282517 m3/s; Flow Rate At 300kPa: 0.00459091 m3/s; Installation and Maintenance: http://static.oras.com/manual/1523F; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 01ls: 180000 Pa; Spare Parts: http://static.oras.com/sp/1523F; Temperature: Temperature limiter, temperature regulator
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1523F(2017); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1523F; Name: 1523F Kitchen faucet, Energy Class C; ReplacementCost: n/a; Shape: Sculptured; Size: 50x240x300 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1523F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1523F Kitchen faucet, Energy Class C
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.100845 m2; Volume: 0.00359305 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1523F(2017): 1523F Kitchen faucet, Energy Class C; Family and Type: 1523F(2017): 1523F Kitchen faucet, Energy Class C; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1523F(2017): 1523F Kitchen faucet, Energy Class C; Type Id: 1523F(2017): 1523F Kitchen faucet, Energy Class C; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
